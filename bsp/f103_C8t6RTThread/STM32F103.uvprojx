# Keil uVision project STM32F103.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\stm32Lib\f103\inc;.\user;.\board;..\stm32Lib\f103\CMSIS;..\stm32Lib\f103\SYS;..\..\skySoftware\include;..\..\examples;..\..\rtthreadNano3.1.3\include;..\stm32Lib\f103\ku\md
  memory RVCT4: ROM 0x8008000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c stm32f10x_it.c
    ./user/: board.c rtconfig.h
  group board
    ./board/: bsp_usart1.c bsp_cmdCtl.c
    ../stm32Lib/f103/ku/md/: stmflash.c
  group SKYSOFT
    ../../skySoftware/src/: communication.c myFIFO.c commonIOInterface.c Public_util.c Public_SoftStringCmd.c
  group FWLIB
    ../stm32Lib/f103/src/: misc.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_can.c stm32f10x_usart.c
  group CMSISI
    ../stm32Lib/f103/CMSIS/: core_cm3.c system_stm32f10x.c
    ../stm32Lib/f103/CMSIS/startup/: startup_stm32f10x_md.s
  group rtthread
    ../../rtthreadNano3.1.3/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../../rtthreadNano3.1.3/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
