# Keil uVision project stm32f407.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\stm32Lib\f4\inc;.\user;.\board;..\stm32Lib\f4\CORE;..\stm32Lib\f4\sys;..\..\skySoftware\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./user/: main.c stm32f4xx_it.c
  group board
    ./board/: driverUsart1.c mypwm.c myadc.c
  group SKYSOFT
    ../../skySoftware/src/: myFIFO.c Public_SoftStringCmd.c Public_SoftI2C.c communication.c commonIOInterface.c
  group SYS
    ../stm32Lib/f4/sys/: delay.c systick.c
  group FWLIB
    ../stm32Lib/f4/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_syscfg.c
  group CMSISI
    ../stm32Lib/f4/CORE/: system_stm32f4xx.c startup_stm32f40_41xxx.s
