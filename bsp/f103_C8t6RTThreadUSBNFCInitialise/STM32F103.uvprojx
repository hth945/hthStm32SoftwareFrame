# Keil uVision project STM32F103.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,PHTALTAMA
  c include: ..\stm32Lib\f103\inc;.\user;.\board;..\stm32Lib\f103\CMSIS;..\stm32Lib\f103\SYS;..\..\skySoftware\include;..\..\examples;..\..\rtthreadNano3.1.3\include;..\stm32Lib\f103\ku\md;.\board\USB\CONFIG;.\board\USB\STM32_USB-FS-Device_Driver\inc;.\..\p2pnfclib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c stm32f10x_it.c
    ./user/: board.c rtconfig.h
  group board
    ./board/: bsp_usart1.c mypwm.c bsp_usart3.c
    ../stm32Lib/f103/ku/md/: stmflash.c
  group SKYSOFT
    ../../skySoftware/src/: communication.c myFIFO.c commonIOInterface.c Public_util.c Public_SoftStringCmd.c
  group FWLIB
    ../stm32Lib/f103/src/: misc.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_can.c stm32f10x_usart.c stm32f10x_tim.c
  group CMSISI
    ../stm32Lib/f103/CMSIS/: core_cm3.c system_stm32f10x.c
    ../stm32Lib/f103/CMSIS/startup/: startup_stm32f10x_md.s startup_stm32f10x_hd.s
  group rtthread
    ../../rtthreadNano3.1.3/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../../rtthreadNano3.1.3/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group USB
    ./board/USB/CONFIG/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
    ./board/USB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group p2pNfclib
    ../p2pnfclib/: nfc32Test.c phDalNfc.c phHalNfc.c phTalTama.c nfcInitialise.c nfcITarget.c
