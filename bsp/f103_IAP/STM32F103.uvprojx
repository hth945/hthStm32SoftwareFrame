# Keil uVision project STM32F103.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\stm32Lib\f103\inc;.\user;.\board;..\stm32Lib\f103\CMSIS;..\stm32Lib\f103\SYS;..\..\skySoftware\include;..\..\examples
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./USER/: main.c stm32f10x_it.c
    ./user/: iapSoftware.c
  group board
    ./board/: bsp_usart1.c bsp_cmdCtl.c stmflash.c bsp_usart5.c
  group SKYSOFT
    ../../skySoftware/src/: communication.c myFIFO.c commonIOInterface.c Public_util.c
  group SYS
    ../stm32Lib/f103/SYS/: delay.c SysTick.c
  group FWLIB
    ../stm32Lib/f103/src/: misc.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_can.c stm32f10x_usart.c
  group CMSISI
    ../stm32Lib/f103/CMSIS/: core_cm3.c system_stm32f10x.c
    ../stm32Lib/f103/CMSIS/startup/: startup_stm32f10x_hd.s
